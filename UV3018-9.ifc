Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Selected elements only], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: On], Option [Convert 2D symbols of Doors and Windows: On], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Element Parameters: Off], Option [IFC Base Quantities: Off], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off]
File name: H:\Blade IFC Files\ICF Group UnikaVaev\UV3018-9.ifc
Time: 2017-07-26T17:08:20
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 20.0.0 AUS FULL Windows version (IFC2x3 add-on version: 5025 AUS FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: -33, -52, 0, 0; RefLongitude: 151, 13, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, GROUND
In: Building
Elevation: 0 mm

# IfcBeam: Blade Vertical Dovetail 10 x 20 (4)
In: GROUND
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_BeamCommon - LoadBearing: yes; IsExternal: no; Reference: Blade Vertical Dovetail 10 x 20

# IfcColumn: 3018 18 x 30 (9)
In: GROUND
Material: Timber
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_ColumnCommon - Reference: 3018 18 x 30
